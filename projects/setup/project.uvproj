# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ../../components/boards/: boards.c
  group Application
    ./: main.c
    ../../examples/peripheral/timer/pca10056/blank/config/: sdk_config.h
